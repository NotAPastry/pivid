/* apps/pivid-player/src/osd_msp_font.c -- BTFL_DJI msp-osd SD font loader.
 * Loads the compiled-in PNG sheet into a Cairo image surface.
 * The test entry point (_from_png) accepts any in-memory PNG buffer. */

#include "osd_msp_font.h"
#include <cairo.h>
#include <stdlib.h>
#include <string.h>

/* Embedded font bytes (generated by EmbedFile.cmake at configure time). */
extern const unsigned char font_btfl_dji_png[];
extern const unsigned      font_btfl_dji_png_len;

/* ---- in-memory PNG stream reader ---------------------------------------- */

struct mem_png { const unsigned char *p; unsigned len, pos; };

static cairo_status_t mem_read(void *closure, unsigned char *data, unsigned int length) {
    struct mem_png *m = closure;
    if (m->pos + length > m->len) return CAIRO_STATUS_READ_ERROR;
    memcpy(data, m->p + m->pos, length);
    m->pos += length;
    return CAIRO_STATUS_SUCCESS;
}

/* ---- OsdMspFont ---------------------------------------------------------- */

struct OsdMspFont {
    cairo_surface_t *sheet;
};

OsdMspFont *osd_msp_font_create_from_png(const unsigned char *buf, unsigned len) {
    struct mem_png m = { buf, len, 0 };
    cairo_surface_t *surf = cairo_image_surface_create_from_png_stream(mem_read, &m);
    if (cairo_surface_status(surf) != CAIRO_STATUS_SUCCESS) {
        cairo_surface_destroy(surf);
        return NULL;
    }
    OsdMspFont *f = malloc(sizeof *f);
    if (!f) {
        cairo_surface_destroy(surf);
        return NULL;
    }
    f->sheet = surf;
    return f;
}

OsdMspFont *osd_msp_font_create(void) {
    return osd_msp_font_create_from_png(font_btfl_dji_png, font_btfl_dji_png_len);
}

void osd_msp_font_destroy(OsdMspFont *f) {
    if (!f) return;
    cairo_surface_destroy(f->sheet);
    free(f);
}

cairo_surface_t *osd_msp_font_sheet(const OsdMspFont *f) {
    return f->sheet;
}

void osd_msp_font_src(unsigned index, double *sx, double *sy) {
    *sx = 0.0;
    *sy = (double)index * OSD_FONT_GH;
}
